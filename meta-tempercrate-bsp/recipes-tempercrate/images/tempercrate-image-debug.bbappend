require tempercrate-flashlayout-common.inc

TEMPERCRATE_FLASHLAYOUT_TSV_SOURCE = "recipes-tempercrate/images/files/FlashLayout_TemperCrate_Debug.tsv"
TEMPERCRATE_FLASHLAYOUT_TSV_DEPLOY = "FlashLayout_TemperCrate_Debug.tsv"
TEMPERCRATE_RAW_IMAGE_OUTPUT_NAME = "FlashLayout_TemperCrate_Debug.raw"