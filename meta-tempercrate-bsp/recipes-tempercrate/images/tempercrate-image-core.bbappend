require tempercrate-flashlayout-common.inc

TEMPERCRATE_FLASHLAYOUT_TSV_SOURCE = "recipes-tempercrate/images/files/FlashLayout_TemperCrate_Core.tsv"
TEMPERCRATE_FLASHLAYOUT_TSV_DEPLOY = "FlashLayout_TemperCrate_Core.tsv"
TEMPERCRATE_RAW_IMAGE_OUTPUT_NAME = "FlashLayout_TemperCrate_Core.raw"