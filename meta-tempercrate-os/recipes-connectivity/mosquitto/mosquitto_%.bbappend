# Enable mosquitto service at boot
SYSTEMD_AUTO_ENABLE:${PN} = "enable"
